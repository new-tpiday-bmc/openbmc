KBRANCH ?= "ops-idm-dev-4.10"
LINUX_VERSION ?= "4.10.17"

SRCREV="1d50786f2610befa67f04641dd8c9aa70a2ab131"

require linux-obmc.inc
