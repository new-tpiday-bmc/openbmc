DEPENDS += "i2c-tools"
SRCREV ?= "8367945f002ce354ff34f49932e0dde990872009"
SKELETON_URI ?= "git://github.com/new-tpiday-bmc/skeleton;branch=ops-idm"
