PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " zaius-thermal-policy-native"
