# Support OCC pass through and general occ control
# Support for GPIO presence service
RDEPENDS_${PN}-inventory_append_zaius = " virtual/obmc-gpio-presence"
